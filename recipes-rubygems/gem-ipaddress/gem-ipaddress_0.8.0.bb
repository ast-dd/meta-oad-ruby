DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/ipaddress"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=52f3a53aa4932dc3fbda4d659f7baa8c"

inherit rubygems

SRC_URI[md5sum] = "c1b274b056650390689360c9856f2180"
SRC_URI[sha256sum] = "398ac94becdbce3151acc8bb3854918c3d11e286e37e7595f082dad4fc259e33"
