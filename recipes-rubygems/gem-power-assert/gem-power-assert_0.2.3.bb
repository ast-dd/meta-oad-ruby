DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/powerassert"
SECTION = "devel/ruby"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://BSDL;md5=048c2b00fd530e0dbb97ebbaee14a2cb"
PR="r1"

GEM_NAME = "power_assert"

inherit rubygems

SRC_URI[md5sum] = "043de3bb45bc6f8a7ec1641e93b0b867"
SRC_URI[sha256sum] = "46dd1fa63023372da145d5fe3b58abb42c7e5f3fa4e265b7d2f5438d4e918127"
