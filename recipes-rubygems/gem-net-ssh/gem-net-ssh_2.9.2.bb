DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/net-ssh"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6c99c0cc0901fbc3607fe997f9898d69"
PR="r1"

inherit rubygems

SRC_URI[md5sum] = "ac7574a89e2b422468d98f5387ceb41e"
SRC_URI[sha256sum] = "19c11b66feb5659b8e4a394f972ef1e9bb5fcac23754da2da485d7fc03910bdc"
