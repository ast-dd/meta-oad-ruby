DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/haml"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=b0debb542a54637fa7caac9f1ca9b4a1"

inherit rubygems

SRC_URI[md5sum] = "a9c0e08df292e1690d3212871ddd2b66"
SRC_URI[sha256sum] = "44f69d51810cfc5a0ffbb03fdc646afb2c2f4f841eacfab87caba02b59ae1617"
