DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/multipart-post"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit rubygems

SRC_URI[md5sum] = "1be431f2e8b50cc5b63cc7b7e23fef44"
SRC_URI[sha256sum] = "3dc44e50d3df3d42da2b86272c568fd7b75c928d8af3cc5f9834e2e5d9586026"
