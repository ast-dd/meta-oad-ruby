DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/hike"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fd65d504a5aea756bba2e5b724c76245"

inherit rubygems

SRC_URI[md5sum] = "ee3bcc471ff5dcd88f020351f8184dd3"
SRC_URI[sha256sum] = "154e2f2593845e5bcd8ed2ba3092600c55c6ad8c630722857de3fdaf334ccc44"
