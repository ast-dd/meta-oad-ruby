DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/i18n"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=c0e4b0e10e0acf26e4e423343ccf78f8"
PR="r1"

inherit rubygems

SRC_URI[md5sum] = "e9f92faf73a805a95c92d42031f4dca3"
SRC_URI[sha256sum] = "a81cd327bd0f2c490ecf9f62f4a91ffaf5061aa2bf22cdbafe1a7e44a70fbfc4"
