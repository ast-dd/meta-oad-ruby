SUMMARY = "A fast JSON parser and serializer."
DESCRIPTION = "The fastest JSON parser and object serializer. "
HOMEPAGE = "http://rubygems.org/gems/oj"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

SRC_URI[md5sum] = "d9ad640573bb37dfbfa85f6f171bb0ca"
SRC_URI[sha256sum] = "815346eb5875710a7302bb103e28598bc14a156df72d27e3d2f4fb78af8864a5"

PR = "r0"

inherit rubygems

