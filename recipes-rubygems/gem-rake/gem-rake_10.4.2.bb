DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/rake"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=b217e3354f829a186a07233cd480fbee"
PR="r1"

inherit rubygems

SRC_URI[md5sum] = "3a1ec419b478db5b0de897eca1fad591"
SRC_URI[sha256sum] = "28970905a7bb57ba7ebcd2eda820ccea622f549b101d7590353b0647711ec0e6"
