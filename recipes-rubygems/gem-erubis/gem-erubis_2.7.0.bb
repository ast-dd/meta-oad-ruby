DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/erubis"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=f2371f979587e069c8f69be911f717bd"

inherit rubygems

SRC_URI[md5sum] = "cca3cf13ef951d1fc8c124d2fde52565"
SRC_URI[sha256sum] = "63653f5174a7997f6f1d6f465fbe1494dcc4bdab1fb8e635f6216989fb1148ba"
