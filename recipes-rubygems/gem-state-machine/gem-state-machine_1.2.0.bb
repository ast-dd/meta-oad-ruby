DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/state-machine"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4f84d3b89f1636641f492aab18819924"

GEM_NAME = "state_machine"

inherit rubygems

SRC_URI[md5sum] = "2bab962d8454a0555097b6c28bce8a98"
SRC_URI[sha256sum] = "80fcddc91976baec8713c37c28b5bc0655f5f2e0a1412a1a4a3aac41082cc2ed"
