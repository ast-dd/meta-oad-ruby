SUMMARY = "A simple API for XML processing."
HOMEPAGE = "http://rubygems.org/gems/xml-simple"
SECTION = "devel/ruby"
LICENSE = "Ruby"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/Ruby;md5=105fc57d3f4d3122db32912f3e6107d0"

SRC_URI[md5sum] = "be57835053eed1385923181619dd5411"
SRC_URI[sha256sum] = "88c33d33ec4e28f11d8479bd89331eabaa651fff5effe9d92d3dbaa11abd9876"

PR = "r0"

inherit rubygems

