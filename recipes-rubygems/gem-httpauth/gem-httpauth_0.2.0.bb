DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/httpauth"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f66d6164676826758b77b1f39945286c"

inherit rubygems

SRC_URI[md5sum] = "b7d84a83557c2957b3e10188609f5636"
SRC_URI[sha256sum] = "61693bd3849f348c075861a014c95af777a89581e04cae231641c56fc2a9e21f"
