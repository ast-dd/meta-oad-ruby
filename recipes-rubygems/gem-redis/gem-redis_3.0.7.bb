DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/redis"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2822f759e526422a3d69ad8b3b134497"

inherit rubygems

SRC_URI[md5sum] = "42142fd4ab1af0003725b02e4a424d68"
SRC_URI[sha256sum] = "94f1efe54f9ce74a0efd909f75bad842fa0a7fe93de66064ef8aae126e0464ca"
