DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/polyglot"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://License.txt;md5=afcdf809f80bace3304b97405686725f"
PR="r2"

inherit rubygems

SRC_URI[md5sum] = "5fff8b0cfb2b36d885b90d271802a7c5"
SRC_URI[sha256sum] = "59d66ef5e3c166431c39cb8b7c1d02af419051352f27912f6a43981b3def16af"
