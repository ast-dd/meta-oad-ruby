SUMMARY = "Run JavaScript code from Ruby"
DESCRIPTION = "ExecJS lets you run JavaScript code from Ruby."
HOMEPAGE = "http://rubygems.org/gems/execjs"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0bf511c7aa2bd1a968ce289aaae39427"

SRC_URI[md5sum] = "f00d13d004bb3ecd8d102d21e98cfcc6"
SRC_URI[sha256sum] = "ee5b3a20506fc0668336cb12e831d39f628db4b2f35612b970c372e93f284a8c"

PR = "r1"

inherit rubygems

