SUMMARY = "Your friendly neighborhood hash library."
DESCRIPTION = "Hashie is a collection of classes and mixins that make hashes more powerful."
HOMEPAGE = "http://rubygems.org/gems/hashie"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

SRC_URI[md5sum] = "de4c4fa85900769d65c64ce688213025"
SRC_URI[sha256sum] = "5e39f20c0087ff8fc415f378427c17dc8cd21fa282b7f26267a863b073655802"

PR = "r0"

inherit rubygems

