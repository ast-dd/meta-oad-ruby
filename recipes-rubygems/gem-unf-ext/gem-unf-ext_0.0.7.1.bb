SUMMARY = "Unicode Normalization Form support library for CRuby"
DESCRIPTION = "Unicode Normalization Form support library for CRuby"
HOMEPAGE = "http://rubygems.org/gems/unf_ext"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6ca1fa10e57f6b051236c822f2f8767f"

SRC_URI[md5sum] = "39bfbb9e124410f57a97d1837f02d42a"
SRC_URI[sha256sum] = "ab58d1a808d38872817bea89fc3f055bfc250af48d9653425e35c7c18caec253"

PR = "r0"

inherit rubygems

GEM_NAME = "unf_ext"
