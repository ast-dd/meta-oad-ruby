DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/websocket-driver"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit rubygems

SRC_URI[md5sum] = "d349a644458b0574bfc2c2f7bce98148"
SRC_URI[sha256sum] = "c232ff2c4fd72332e5b8bb5475fd2575ed6aa4462c9d5556c3c5c95073ab7480"
