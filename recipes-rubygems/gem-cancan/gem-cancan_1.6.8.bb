DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/cancan"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=16a1786531ee5e4c7832a2a03e73b443"

inherit rubygems

SRC_URI[md5sum] = "4de192d4747841d6e53e79c62b7e4868"
SRC_URI[sha256sum] = "a29d5892d4897329f1b646953a00494dcc6d2e9a026d2d5a582f6fd8a9240a32"
