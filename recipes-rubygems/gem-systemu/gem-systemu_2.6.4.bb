DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/systemu"
SECTION = "devel/ruby"
LICENSE = "Ruby"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/Ruby;md5=105fc57d3f4d3122db32912f3e6107d0"

inherit rubygems

SRC_URI[md5sum] = "1d00c079a064d6c2bc5cbd6c7ec8ca48"
SRC_URI[sha256sum] = "5f8c38d0a483f1999aaacac3022bcea4dc6bf524537b93514939787dbf22699a"
