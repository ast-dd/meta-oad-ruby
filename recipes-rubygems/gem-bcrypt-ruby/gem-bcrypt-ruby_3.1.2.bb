DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/bcrypt-ruby"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=64bd8a0d3896c920e7ff8ca686d2fe13"
PR="r1"

inherit rubygems

SRC_URI[md5sum] = "a85f11df1bcadba1f6ad10053c3c1af8"
SRC_URI[sha256sum] = "e3857f0e4f5ecbd8bbfd3f6e662aba80e4fbc60a4c78b4771bcc074b0d50f8e7"
