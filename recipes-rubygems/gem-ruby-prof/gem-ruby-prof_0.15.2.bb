DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/ruby-prof"
SECTION = "devel/ruby"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=88d67f7c0ea2e6f59a24d4faa713de44"

inherit rubygems

SRC_URI[md5sum] = "f432c1d84f16b7bb06a87f35466bcab3"
SRC_URI[sha256sum] = "9466770f313ef3d668a298be691cfdb25d9d938c7c78a873467c0dd896d87631"
