DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/orm-adapter"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4189f0604311287e1163104c1e18ab1d"

GEM_NAME = "orm_adapter"

inherit rubygems

SRC_URI[md5sum] = "08702bf6f1f0c548e4d29aa236ef2a1c"
SRC_URI[sha256sum] = "aa5d0be5d540cbb46d3a93e88061f4ece6a25f6e97d6a47122beb84fe595e9b9"
