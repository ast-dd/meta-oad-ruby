DESCRIPTION = "A ruby gem to parse config files"
HOMEPAGE = "http://rubygems.org/gems/parseconfig"
SECTION = "devel/ruby"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=11c24eb320aa01b5b0d68fe656cf4d3f"


inherit rubygems

SRC_URI[md5sum] = "be2e2b01bb94556b530e01bf11b04d5f"
SRC_URI[sha256sum] = "7dd89d150ad5b8c0b727d2bbdd94a6dc501e6503732412fa50ea4c7601890bbe"
