DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/inflecto"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b16bbab06e41adca6d79448cd927327b"

inherit rubygems


SRC_URI[md5sum] = "d6c1c7fca35f737d9fc6e4800b766fe5"
SRC_URI[sha256sum] = "e4ea51d7b1bae9580e50059084273b26bf518722853c59784d85e35dbb2ab420"
