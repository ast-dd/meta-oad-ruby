DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/oauth"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=755b72a0d004675c51ffe503df5c8664"

inherit rubygems

SRC_URI[md5sum] = "e8a766489798a2275ac8ea5d7a1512d9"
SRC_URI[sha256sum] = "bca47d77c946af466872269e37e470837858b1305d5143e5a56c50356e02b2cc"
