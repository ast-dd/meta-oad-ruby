DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/will-paginate"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=bd7c7029ef620d44ac919e02ac712448"

GEM_NAME = "will_paginate"

inherit rubygems

SRC_URI[md5sum] = "55ea859b0a174674a64dc1d5d3aa70cb"
SRC_URI[sha256sum] = "49ec0239005b65efec4c762e187674ff9963a1a82123fa4b01d1bc037381abcb"
