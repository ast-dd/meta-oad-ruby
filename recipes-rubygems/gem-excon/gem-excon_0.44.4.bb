DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/excon"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
PR="r1"

inherit rubygems

SRC_URI[md5sum] = "e3c3d72a733adff3b343f3334ac778d3"
SRC_URI[sha256sum] = "e5ae17c2d4e4ae6b92aa0859a7cf40226ad5467d1859f369e0a4c7af5ab65e18"
