DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/chronic"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c5adbaac0d73e5e057f99a80795ef95b"

inherit rubygems

SRC_URI[md5sum] = "08a655a971a93f476e2a827365973f57"
SRC_URI[sha256sum] = "766f2fcce6ac3cc152249ed0f2b827770d3e517e2e87c5fba7ed74f4889d2dc3"
