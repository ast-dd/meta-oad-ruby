DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/formatador"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
PR="r1"

inherit rubygems

SRC_URI[md5sum] = "f2d7213efd6a327ec6c34262185f6e2e"
SRC_URI[sha256sum] = "80821869ddacb79e72870ff4bb1531efacd278c04f2df26bc6b4529ee13582bd"
