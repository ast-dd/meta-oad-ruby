DESCRIPTION = "A ruby gem"
HOMEPAGE = "http://rubygems.org/gems/encrypted-strings"
SECTION = "devel/ruby"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c008ed5646294b80b34d25291a52beed"

GEM_NAME = "encrypted_strings"

inherit rubygems

SRC_URI[md5sum] = "0bf5460f41eda3d94a082fe2e8e3e0e6"
SRC_URI[sha256sum] = "43cebc9c7c7208c4f3eb32b592746df4cabd91fc4511e47ea631599a016ed076"
